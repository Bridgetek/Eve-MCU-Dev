# Keil uVision project project.uvprojx, settings and files
target fontmagic_stm32 (6220000::V6.22::ARMCLANG)
  device: STM32F030R8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: fontmagic_stm32
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: PLATFORM_STM32
  c include: ..\common;..\..\snippets;..\..\..\include;..\..\..\source\extensions;..\..\snippets
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group EVE Example
    ../../snippets/: touch.c
    ../../snippets/controls/: fonts.c
    ../common/: eve_example.c eve_fonts.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F030R8Tx/STCubeGenerated/Src/: main.c stm32f0xx_it.c
    ./RTE/Device/STM32F030R8Tx/STCubeGenerated/Inc/: stm32f0xx_it.h
  group EVE Library Source
    ../../../source/: EVE_API.c EVE_HAL.c
  group EVE Library Ports
    ../../../ports/eve_arch_stm32/: EVE_MCU_STM32.c
  group EVE BT82x Code
    ../../../source/extensions/: patch_base.c
  group EVE Custom Touch Code
    ../../../source/extensions/: custom_touch.c
software components: CMSIS Driver:GPIO:Custom 1.0.0, CMSIS:CORE 6.1.0, CMSIS Driver:SPI 1.0.0, Device:STM32Cube Framework:STM32CubeMX 1.1.0, Device:STM32Cube HAL 1.11.3
